# Keil uVision project USART_Polling.uvprojx, settings and files
target APM32F030 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F030R8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USART_Polling
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F030_MINI,APM32F030x8
  c include: ..\Library\APM32F0xx_StdPeriphDriver\inc;..\Library\CMSIS\Include;..\Library\Device\Geehy\APM32F0xx\Include;..\Board;..\Booter;..\pikascript\pikascript-core;..\pikascript\pikascript-api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../Library/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
  group StdPeriphLib
    ../Library/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_eint.c apm32f0xx_gpio.c apm32f0xx_rcm.c apm32f0xx_usart.c apm32f0xx_misc.c
  group Booter
    ../Booter/: main.c apm32f0xx_int.c startup_apm32f030.s
  group pikascript-core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_MemChecker.c PikaStdLib_SysObj.c
  group pikascript-api
    ../pikascript/pikascript-api/: PikaMain-api.c pikaScript.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdLib-api.c
target APM32F072 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F072VB Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USART_Polling
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F072_MINI,APM32F072xB
  c include: ..\..\..\..\..\Library\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\Board;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
