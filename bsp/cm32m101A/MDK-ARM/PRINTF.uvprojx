# Keil uVision project PRINTF.uvprojx, settings and files
target Sprrow Board (6160000::V6.16::ARMCLANG)
  device: CM32M101A-L64 CMIOT
  pack: China Mobile IOT Company Limited(CMIOT).CM32M101A_DFP.0.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CM32M101A_Proj +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\BSP\inc;..\CMSIS\core;..\CMSIS\device;..\Firmware\cm32m101a_algo_lib\inc;..\Firmware\cm32m101a_std_periph_driver\inc;..\Firmware\cm32m101a_usbfs_driver\inc;..\App\inc;..\PikaScript\pikascript-core;..\PikaScript\pikascript-api;..\PikaScript\pikascript-lib\CM32M101ABooter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ../PikaScript/pikascript-lib/CM32M101ABooter/: main.c cm32m101a_it.c
  group BSP
    ../PikaScript/pikascript-lib/CM32M101ABooter/: share.c key_poll.c led.c key_exti.c relay.c uart.c
  group Firmware
    ../Firmware/cm32m101a_std_periph_driver/src/: cm32m101a_adc.c cm32m101a_can.c cm32m101a_comp.c cm32m101a_crc.c cm32m101a_dac.c cm32m101a_dbg.c cm32m101a_dma.c cm32m101a_exti.c cm32m101a_flash.c cm32m101a_gpio.c cm32m101a_i2c.c cm32m101a_iwdg.c cm32m101a_lcd.c cm32m101a_lprcnt.c cm32m101a_lptim.c cm32m101a_lpuart.c cm32m101a_opamp.c cm32m101a_pwr.c cm32m101a_rcc.c cm32m101a_rtc.c cm32m101a_spi.c cm32m101a_tim.c cm32m101a_tsc.c cm32m101a_usart.c cm32m101a_wwdg.c misc.c
  group CMSIS
    ../PikaScript/pikascript-lib/CM32M101ABooter/: system_cm32m101a.c startup_cm32m101a.s
  group pikascript-core
    ../PikaScript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group pikascript-api
    ../PikaScript/pikascript-api/: PikaMain-api.c pikaScript.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdLib-api.c
  group pikascript-lib
    ../PikaScript/pikascript-lib/PikaStdLib/: PikaStdLib_MemChecker.c PikaStdLib_SysObj.c
