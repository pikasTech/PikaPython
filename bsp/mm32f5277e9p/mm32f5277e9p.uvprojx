# Keil uVision project mm32f5277e9p.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MM32F5277E9P MindMotion
  pack: MindMotion.MM32F5277E_DFP.0.0.4
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: mm32f5277e9p
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=1 wLevel=3
  c include: .\Files\PikaScript\pikascript-api;.\Files\PikaScript\pikascript-core;.\Files\device\drivers;.\Files\device\CMSIS\Include;.\Files\my;.\Files\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: .\Files\device\mdk\linker\mm32f5277e_flash.scf
  group user
    ./Files/: main.c
    ./Files/my/: board_init.c board_init.h clock_init.c clock_init.h pin_init.c pin_init.h
  group pikascript-api
    ./Files/PikaScript/pikascript-api/: __asset_pikaModules_py_a.c PikaDebug_Debuger-api.c PikaDebug-api.c PikaMain-api.c pikaScript.c PikaStdData_ByteArray-api.c PikaStdData_Dict-api.c PikaStdData_List-api.c PikaStdData_String-api.c PikaStdData_Utils-api.c PikaStdData-api.c PikaStdLib_MemChecker-api.c PikaStdLib_PikaObj-api.c PikaStdLib_RangeObj-api.c PikaStdLib_StringObj-api.c PikaStdLib_SysObj-api.c PikaStdLib-api.c PikaStdTask_Task-api.c PikaStdTask-api.c
  group pikascript-core
    ./Files/PikaScript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c PikaCompiler.c
  group pikascript-lib
    ./Files/PikaScript/pikascript-lib/PikaStdLib/: PikaDebuger_Debuger.c PikaStdData_Dict.c PikaStdData_List.c PikaStdData_String.c PikaStdLib_MemChecker.c PikaStdLib_RangeObj.c PikaStdLib_StringObj.c PikaStdLib_SysObj.c PikaStdTask_Task.c PikaStdData_Utils.c
  group devices
    ./Files/device/: hal_device_registers.h mm32f5277e.h mm32f5277e_features.h system_mm32f5277e.c system_mm32f5277e.h
    ./Files/device/mdk/: startup_mm32f5277e.s
  group drviers
    ./Files/device/drivers/: hal_adc.c hal_adc.h hal_common.h hal_comp.c hal_comp.h hal_crc.c hal_crc.h hal_dac.c hal_dac.h hal_dma.c hal_dma.h hal_dma_request.h hal_exti.c hal_exti.h hal_flexcan.c hal_flexcan.h hal_fsmc.c hal_fsmc.h hal_gpio.c hal_gpio.h hal_iwdg.c hal_iwdg.h hal_lpuart.c hal_lpuart.h hal_mds.c hal_mds.h hal_mds_remap.h hal_power.c hal_power.h hal_pwr.c hal_pwr.h hal_qspi.c hal_qspi.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
