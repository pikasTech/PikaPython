# Keil uVision project example.uvprojx, settings and files
target example_arm_compiler_6 (6170000::V6.17::.\Arm Compiler 6.17)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: example
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: __PERF_CNT_USE_LONG_CLOCK__
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: Blinky.sct
  group application
    ./: stdout_USART.c main.c platform.c
  group perf_counter_lib
    ../: perf_counter.c perf_counter.h systick_wrapper_ual.s
    ../lib/: perf_counter.lib
target library (6170000::V6.17::.\Arm Compiler 6.17)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: perf_counter (library)
  AfterMake: copy.bat
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: Blinky.sct
target example_arm compiler_5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: example
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: __PERF_CNT_USE_LONG_CLOCK__
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: Blinky.sct
software components: CMSIS:CORE 5.5.0, Device:Startup 1.2.2, Utilities:Performance:perf_counter 1.6.0, Compiler:I/O:STDOUT 1.2.0
