# Keil uVision project gcc_example.uvprojx, settings and files
target example (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: gcc_example
  group startup
    ./gcc/: startup_ARMCM0.c system_ARMCM0.c
  group application
    ./: main.c platform.c stdout_USART.c
  group perf_counter
    ../: perf_counter.c perf_counter.h systick_wrapper_gcc.s
target gcc_lib (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: perf_counter_gcc (library)
  AfterMake: copy.bat
software components: CMSIS:CORE 5.5.0, Utilities:Performance:perf_counter 1.6.1
