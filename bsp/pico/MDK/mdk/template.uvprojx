# Keil uVision project template.uvprojx, settings and files
target AC6-DebugInSRAM-printf (6180000::V6.18::ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: template
  BeforeMake: ..\..\\pikascript\pikaBeforBuild-keil.bat
  AfterMake: .\axf2uf2.bat
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: PICO, NDEBUG, PICO_NO_FLASH, USE_EVR_FOR_STDOUR
  c misc: -include env_wrapper.h
  c include: ..\..\pico-sdk\src\rp2040\hardware_structs\include;..\..\pico-sdk\src\rp2_common\cmsis\include\cmsis;..\..\pico-sdk\src\rp2_common\cmsis\stub\CMSIS\Device\RaspberryPi\RP2040\Include;..\..\pico-sdk\src\boards\include\boards;..\..\pico-sdk\src\rp2040\hardware_regs\include;.\wrapper;..\..\pico-sdk\src\rp2_common\hardware_base\include;..\..\pico-sdk\src\rp2_common\hardware_watchdog\include;..\..\pico-sdk\src\rp2_common\hardware_pll\include;..\..\pico-sdk\src\rp2_common\hardware_xosc\include;..\..\pico-sdk\src\rp2_common\hardware_irq\include;..\..\pico-sdk\src\rp2_common\hardware_gpio\include;..\..\pico-sdk\src\rp2_common\hardware_resets\include;..\..\pico-sdk\src\rp2_common\hardware_clocks\include;..\..\pico-sdk\src\rp2_common\hardware_timer\include;..\..\pico-sdk\src\rp2_common\hardware_sync\include;..\..\pico-sdk\src\rp2_common\hardware_claim\include;..\..\pico-sdk\src\rp2_common\hardware_spi\include;..\..\pico-sdk\src\rp2_common\hardware_pwm\include;..\..\pico-sdk\src\rp2_common\hardware_i2c\include;..\..\pico-sdk\src\rp2_common\hardware_uart\include;..\..\pico-sdk\src\rp2_common\hardware_adc\include;..\..\pico-sdk\src\common\pico_base\include;..\..\pico-sdk\src\rp2_common\pico_multicore\include;..\..\pico-sdk\src\common\pico_sync\include;..\..\pico-sdk\src\common\pico_time\include;..\..\pico-sdk\src\common\pico_util\include;..\..\pico-sdk\src\common\pico_stdlib\include;..\..\pico-sdk\src\rp2_common\pico_stdio\include;..\..\pico-sdk\src;..\..\pico-sdk\src\rp2_common\pico_runtime\include;..\..\pico-sdk\src\rp2_common\pico_printf\include;..\..\pico-sdk\src\rp2_common\pico_bootrom\include;..\..\pico-sdk\src\rp2_common\pico_stdio\include;..\..\pico-sdk\src\rp2_common\pico_stdio_uart\include;..\..\pico-sdk\src\rp2_common\pico_stdio_usb\include;..\..\pico-sdk\src\common\pico_binary_info\include;..\..\pico-sdk\src\rp2_common\pico_stdio_semihosting\include;..\..\pico-sdk\src\rp2_common\boot_stage2\include;.\wrapper\pico_base;..\..\pikascript\pikascript-lib/PikaStdLib;..\..\pikascript\pikascript-api;..\..\pikascript\pikascript-core
  asm define: PICO_MAX_SHARED_IRQ_HANDLERS=4,LIB_CMSIS_CORE=1,PICO_CMSIS_RENAME_EXCEPTIONS=1
  asm include: ..\..\pico-sdk\src\rp2040\hardware_regs\include;..\..\pico-sdk\src\rp2_common\hardware_irq\include;..\..\pico-sdk\src\rp2_common\pico_platform\include;..\..\pico-sdk\src\common\pico_base\include;.\wrapper\pico_base;..\..\pico-sdk\src\rp2_common\boot_stage2\asminclude;..\..\pico-sdk\src\rp2_common\boot_stage2\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RP2040_debug_in_sram.sct
  link misc: --diag_suppress=L6170,L6314,L6306,L6329 --entry=Reset_Handler
  group Pico-SDK
    ./: startup_RP2040.c
    ../../pico-sdk/src/rp2_common/cmsis/stub/CMSIS/Device/RaspberryPi/RP2040/Source/: system_RP2040.c
    ../../pico-sdk/src/rp2_common/hardware_clocks/: clocks.c
    ../../pico-sdk/src/rp2_common/hardware_watchdog/: watchdog.c
    ../../pico-sdk/src/rp2_common/hardware_pll/: pll.c
    ../../pico-sdk/src/rp2_common/pico_platform/: platform.c
    ../../pico-sdk/src/rp2_common/hardware_xosc/: xosc.c
    ../../pico-sdk/src/rp2_common/hardware_irq/: irq.c irq_handler_chain.S
    ../../pico-sdk/src/rp2_common/hardware_gpio/: gpio.c
    ../../pico-sdk/src/rp2_common/pico_multicore/: multicore.c
    ../../pico-sdk/src/rp2_common/hardware_sync/: sync.c
    ../../pico-sdk/src/common/pico_sync/: critical_section.c lock_core.c mutex.c sem.c
    ../../pico-sdk/src/common/pico_time/: time.c timeout_helper.c
    ../../pico-sdk/src/rp2_common/hardware_timer/: timer.c
    ../../pico-sdk/src/rp2_common/hardware_claim/: claim.c
    ../../pico-sdk/src/common/pico_util/: queue.c pheap.c datetime.c
    ../../pico-sdk/src/host/pico_stdlib/: stdlib.c
    ../../pico-sdk/src/rp2_common/hardware_uart/: uart.c
    ../../pico-sdk/src/rp2_common/boot_stage2/: compile_time_choice.S boot2_w25q080.S
    ./wrapper/: runtime.c
    ../../pico-sdk/src/rp2_common/pico_printf/: printf_none.S
    ../../pico-sdk/src/rp2_common/hardware_i2c/: i2c.c
    ../../pico-sdk/src/rp2_common/hardware_spi/: spi.c
    ../../pico-sdk/src/rp2_common/hardware_adc/: adc.c
    ../../pico-sdk/src/rp2_common/pico_bootrom/: bootrom.c
    ../../pico-sdk/src/rp2_common/pico_stdio_uart/: stdio_uart.c
    ../../pico-sdk/src/rp2_common/pico_standard_link/: binary_info.c
  group platform
    ./wrapper/: env_wrapper.h env_wrapper.c stdio.c
    ./wrapper/pico/: platform.h
    ./wrapper/hardware/: sync.h
  group Application
    ../../: main.c
  group pikascript-lib
    ../../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_RangeObj.c PikaStdData_Dict.c PikaStdTask_Task.c PikaStdLib_StringObj.c PikaStdData_Tuple.c PikaStdLib_MemChecker.c PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_String.c PikaStdData_Utils.c PikaStdData_List.c PikaStdLib_SysObj.c PikaStdData_FILEIO.c
  group pikascript-api
    ../../pikascript/pikascript-api/: PikaStdData_FILEIO-api.c PikaStdLib-api.c PikaStdLib_PikaObj-api.c PikaStdData_Dict-api.c pikaScript.c PikaStdData_Tuple-api.c PikaStdTask_Task-api.c PikaDebug-api.c PikaStdData_List-api.c PikaDebug_Debuger-api.c PikaStdLib_RangeObj-api.c PikaMain-api.c PikaStdData-api.c PikaStdData_ByteArray-api.c PikaStdData_Utils-api.c PikaStdLib_StringObj-api.c PikaStdData_String-api.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdTask-api.c PikaStdData_dict_keys-api.c __asset_pikaModules_py_a.c
  group Python
    ../../pikascript/: main.py
  group pikascript-core
    ../../pikascript/pikascript-core/: dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c BaseObj.c dataArg.c dataArgs.c dataLink.c PikaCompiler.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
software components: CMSIS:CORE 5.5.0, Utilities:perf_counter:Core 1.7.6, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
