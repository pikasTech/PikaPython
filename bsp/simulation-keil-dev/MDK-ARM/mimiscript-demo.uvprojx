# Keil uVision project mimiscript-demo.uvprojx, settings and files
target pikascriptt-demo (6160000::V6.16::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pikascriptt-demo +hex
  BeforeMake: ..\pikascript\pikaBeforBuild-keil.bat
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,__VM_DEBUG__
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\pikascript\pikascript-api;..\..\..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_SysObj.c PikaStdLib_MemChecker.c PikaStdLib_RangeObj.c
    ../pikascript/pikascript-lib/Device/: Device_Led.c Device_Uart.c
    ../pikascript/pikascript-lib/PikaStdData/: PikaStdData_Dict.c PikaStdData_List.c
  group pikascript-api
    ../pikascript/pikascript-api/: Device_LED-api.c Device_Uart-api.c Device-api.c PikaMain-api.c pikaScript.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdLib-api.c PikaStdLib_RangeObj-api.c PikaStdData_Dict-api.c PikaStdData_List-api.c PikaStdData-api.c
  group pikascript-core-latest
    ../../../src/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group python
    ../pikascript/: main.py Device.py PikaObj.py PikaStdLib.py
software components: CMSIS:CORE 5.5.0
