# Keil uVision project Pika_F051.uvprojx, settings and files
target stm32f051r8 (6160000::V6.16::ARMCLANG)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: stm32f051r8 +hex
  BeforeMake: ..\PikaScript\pikaBeforBuild-keil.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F051x8,USE_HAL_DRIVER,STM32F051x8
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\PikaScript\pikascript-api;..\PikaScript\pikascript-core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
  group Pika_Core
    ../PikaScript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group Pika_Api
    ../PikaScript/pikascript-api/: PikaMain-api.c pikaScript.c PikaStdLib_MemChecker-api.c PikaStdLib_RangeObj-api.c PikaStdLib_StringObj-api.c PikaStdLib_SysObj-api.c PikaStdLib-api.c
  group Pika_Lib
    ../PikaScript/pikascript-lib/PikaStdLib/: PikaStdLib_MemChecker.c PikaStdLib_RangeObj.c PikaStdLib_StringObj.c PikaStdLib_SysObj.c
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
software components: CMSIS:CORE 5.5.0
