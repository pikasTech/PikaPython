# Keil uVision project stm32f103c8.uvprojx, settings and files
target stm32f103c8 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32f103c8 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\pikascript\pikascript-lib\STM32F103C8Booter;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\pikascript\pikascript-core;..\pikascript\pikascript-lib\STM32F1;..\pikascript\pikascript-api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Booter
    ../pikascript/pikascript-lib/STM32F103C8Booter/: gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group pikascript-core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group pikascript-api
    ../pikascript/pikascript-api/: PikaMain-api.c pikaScript.c PikaStdDevice_ADC-api.c PikaStdDevice_GPIO-api.c PikaStdDevice_IIC-api.c PikaStdDevice_PWM-api.c PikaStdDevice_Time-api.c PikaStdDevice_UART-api.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdLib-api.c STM32F1_GPIO-api.c STM32F1_lowLevel-api.c STM32F1_Time-api.c STM32F1-api.c STM32F1_ADC-api.c STM32F1_IIC-api.c STM32F1_PWM-api.c STM32F1_UART-api.c
  group pikascript-lib
    ../pikascript/pikascript-lib/STM32F1/: STM32F1_common.c STM32F1_GPIO.c STM32F1_IIC.c STM32F1_PWM.c STM32F1_UART.c STM32F1_ADC.c STM32F1_Time.c
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_MemChecker.c PikaStdLib_SysObj.c
    ../pikascript/pikascript-lib/PikaStdDevice/: PikaStdDevice_ADC.c PikaStdDevice_GPIO.c PikaStdDevice_IIC.c PikaStdDevice_PWM.c PikaStdDevice_Time.c PikaStdDevice_UART.c
software components: CMSIS:CORE 5.5.0
