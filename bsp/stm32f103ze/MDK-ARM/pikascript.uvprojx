# Keil uVision project pikascript.uvprojx, settings and files
target pikascript (6180000::V6.18::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: pikascript +hex
  BeforeMake: ..\pikascript\pikaBeforBuild-keil.bat
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\pikascript\pikascript-lib/PikaStdDevice;..\pikascript\pikascript-lib/STM32F1;..\pikascript\pikascript-lib/PikaStdLib;..\pikascript\pikascript-api;..\pikascript\pikascript-core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group pikascript-core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c PikaCompiler.c
  group pikascript-api
    ../pikascript/pikascript-api/: STM32F1_lowLevel-api.c STM32F1_ADC-api.c PikaStdData_FILEIO-api.c PikaStdLib-api.c PikaStdDevice_CAN-api.c PikaStdDevice_BaseDev-api.c PikaStdLib_PikaObj-api.c STM32F1_IIC-api.c PikaStdData_Dict-api.c pikaScript.c PikaStdDevice_SPI-api.c STM32F1_PWM-api.c PikaStdData_Tuple-api.c PikaStdTask_Task-api.c PikaStdDevice_UART-api.c PikaStdDevice-api.c PikaStdDevice_IIC-api.c PikaStdDevice_GPIO-api.c PikaDebug-api.c PikaStdDevice_PWM-api.c PikaStdData_List-api.c PikaStdDevice_Time-api.c PikaDebug_Debuger-api.c PikaStdLib_RangeObj-api.c PikaMain-api.c PikaStdData-api.c STM32F1_GPIO-api.c PikaStdData_ByteArray-api.c PikaStdData_Utils-api.c PikaStdLib_StringObj-api.c PikaStdData_String-api.c STM32F1_UART-api.c STM32F1-api.c STM32F1_Time-api.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdDevice_ADC-api.c PikaStdTask-api.c PikaStdData_dict_keys-api.c __asset_pikaModules_py_a.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdDevice/: PikaStdDevice_IIC.c PikaStdDevice_ADC.c PikaStdDevice_BaseDev.c PikaStdDevice_GPIO.c PikaStdDevice_CAN.c PikaStdDevice_Time.c PikaStdDevice_UART.c PikaStdDevice_PWM.c PikaStdDevice_SPI.c
    ../pikascript/pikascript-lib/STM32F1/: STM32F1_PWM.c STM32F1_ADC.c STM32F1_IIC.c STM32F1_Time.c STM32F1_common.c STM32F1_GPIO.c STM32F1_UART.c
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_RangeObj.c PikaStdData_Dict.c PikaStdTask_Task.c PikaStdLib_StringObj.c PikaStdData_Tuple.c PikaStdLib_MemChecker.c PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_String.c PikaStdData_Utils.c PikaStdData_List.c PikaStdLib_SysObj.c PikaStdData_FILEIO.c
  group python
    ../pikascript/: main.py
software components: CMSIS:CORE 5.4.0
