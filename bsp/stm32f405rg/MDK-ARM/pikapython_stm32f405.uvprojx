# Keil uVision project pikapython_stm32f405.uvprojx, settings and files
target pikapython_stm32f405 (6180000::V6.18::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: pikapython_stm32f405 +hex
  BeforeMake: ..\pikapython\pikaBeforBuild-keil.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\pikapython\pikascript-lib/PikaStdDevice;..\pikapython\pikascript-lib/STM32;..\pikapython\pikascript-lib/PikaStdLib;..\pikapython\pikascript-api;..\pikapython\pikascript-core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group pikapython/pikascript-core
    ../pikapython/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaCompiler.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group pikapython/pikascript-api
    ../pikapython/pikascript-api/: pikaScript.c __pikaBinding.c __asset_pikaModules_py_a.c
  group pikapython/pikascript-lib
    ../pikapython/pikascript-lib/PikaStdDevice/: pika_hal_SOFT_IIC.c PikaStdDevice_IIC.c PikaStdDevice_ADC.c PikaStdDevice_Timer.c PikaStdDevice_BaseDev.c pika_hal_utils.c PikaStdDevice_common.c PikaStdDevice_GPIO.c PikaStdDevice_CAN.c pika_hal_SOFT_TIM.c PikaStdDevice_UART.c PikaStdDevice_PWM.c pika_hal.c PikaStdDevice_SPI.c pika_hal_SOFT_SPI.c PikaStdDevice_DAC.c
    ../pikapython/pikascript-lib/STM32/: pika_hal_stm32_ADC.c pika_hal_stm32_DAC.c pika_hal_stm32_common.c pika_hal_stm32_time.c pika_hal_stm32_UART.c pika_hal_stm32_PWM.c pika_hal_stm32_GPIO.c
    ../pikapython/pikascript-lib/PikaStdLib/: PikaStdLib_RangeObj.c PikaStdData_Dict.c PikaStdTask_Task.c PikaStdLib_StringObj.c PikaStdData_Tuple.c PikaStdLib_MemChecker.c PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_String.c PikaStdData_Utils.c PikaStdData_List.c PikaStdLib_SysObj.c PikaStdData_FILEIO.c
software components: CMSIS:CORE 5.6.0
