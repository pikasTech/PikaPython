# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,NDEBUG
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4xx_HAL_Driver\inc;..\USER\LED;..\USER\LCD;..\USER\BEEP;..\USER\KEY;..\USER\LCD;..\Arm-2D\Library\Include;..\Arm-2D\Helper\Include;..\pikascript\pikascript-core;..\USER\UART;..\pikascript\pikascript-api
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c stm32f4xx_hal_msp.c startup_stm32f407xx.s cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group USER
    ../USER/LED/: led.c
    ../USER/BEEP/: beep.c
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/UART/: uart.c
  group STM32F4_HAL_FWLIB
    ../STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c
  group Common
    ../Common/: common.c
  group Arm-2D
    ../Arm-2D/Library/Source/: arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_helium.c arm_2d_op_table.c arm_2d_rotation.c arm_2d_tile.c
  group Arm-2D-Helper
    ../Arm-2D/Helper/Source/: arm_2d_helper_pfb.c
  group PikaScript-Core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataString.c dataStrs.c method.c MimiClass.c MimiObj.c SysObj.c TinyObj.c
  group PikaScript-Api
    ../pikascript/pikascript-api/: PikaMain-api.c MemoryChecker-api.c Box-api.c
  group PikaScript-Impl
    ../pikascript/pikascript-impl/: MemoryChecker.c Box.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
