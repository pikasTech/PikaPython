# Keil uVision project Pika_F407.uvprojx, settings and files
target Pika_F407 (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Pika_F407 +hex
  BeforeMake: ..\pikascript\pikaBeforBuild-keil.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\PikaScript\pikascript-lib/PikaStdLib;..\PikaScript\pikascript-api;..\PikaScript\pikascript-core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group PikaScript-lib
    ../PikaScript/pikascript-lib/PikaStdLib/: PikaStdLib_RangeObj.c PikaStdData_Dict.c PikaStdTask_Task.c PikaStdLib_StringObj.c PikaStdData_Tuple.c PikaStdLib_MemChecker.c PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_String.c PikaStdData_Utils.c PikaStdData_List.c PikaStdLib_SysObj.c PikaStdData_FILEIO.c
    ../PikaScript/pikascript-lib/STM32F4/: STM32F4_ADC.c STM32F4_common.c STM32F4_GPIO.c STM32F4_IIC.c STM32F4_PWM.c STM32F4_Time.c STM32F4_UART.c
    ../PikaScript/pikascript-lib/PikaStdDevice/: pika_hal.c PikaStdDevice_ADC.c PikaStdDevice_BaseDev.c PikaStdDevice_CAN.c PikaStdDevice_GPIO.c PikaStdDevice_IIC.c PikaStdDevice_PWM.c PikaStdDevice_SPI.c PikaStdDevice_Time.c PikaStdDevice_UART.c
  group PikaScript-core
    ../PikaScript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c PikaCompiler.c
  group PikaScript-api
    ../PikaScript/pikascript-api/: pikaScript.c __pikaBinding.c __asset_pikaModules_py_a.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
