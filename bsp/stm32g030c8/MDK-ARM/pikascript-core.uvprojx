# Keil uVision project pikascript-core.uvprojx, settings and files
target stm32g030c8 (6160000::V6.16::ARMCLANG)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g030c8 +hex (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx,HAL_ADC_MODULE_ENABLED,HAL_UART_MODULE_ENABLED,HAL_USART_MODULE_ENABLED,HAL_TIM_MODULE_ENABLED
  c include: ../Core/Inc;          ../Drivers/STM32G0xx_HAL_Driver/Inc;          ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;          ../Drivers/CMSIS/Include;          ..\pikascript\pikascript-core;          ..\pikascript\pikascript-api;          ..\pikascript\pikascript-lib\STM32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group pikascript-core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataString.c dataStrs.c method.c PikaBlock.c PikaIf.c PikaInvoke.c PikaObj.c PikaWhile.c TinyObj.c
