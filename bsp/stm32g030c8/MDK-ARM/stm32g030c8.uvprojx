# Keil uVision project stm32g030c8.uvprojx, settings and files
target stm32g030c8 (6180000::V6.18::ARMCLANG)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g030c8 +hex
  BeforeMake: ..\pikascript\pikaBeforBuild-keil.bat
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32G030xx,USE_HAL_DRIVER,PIKA_CONFIG_ENABLE
  c misc: -Wno-error=armcc-pragma-import -Wno-error=armcc-pragma-arm
  c include: ../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\Booter;..\pikascript\pikascript-lib/PikaStdDevice;..\pikascript\pikascript-lib/STM32G0;..\pikascript\pikascript-lib/PikaPiZero;..\pikascript\pikascript-lib/PikaStdLib;..\pikascript\pikascript-api;..\pikascript\pikascript-core
  asm define: ASM_DEFINE_USER_HEAP_SIZE=0x01A00
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Booter
    ../Booter/: gpio.c main.c stm32g0xx_hal_msp.c stm32g0xx_it.c system_stm32g0xx.c startup_stm32g030xx.s pika_config.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal.c stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_crc.c stm32g0xx_ll_crs.c stm32g0xx_ll_dac.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_lptim.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rng.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c stm32g0xx_hal_gpio.c stm32g0xx_hal_cortex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c
  group pikascript-api
    ../pikascript/pikascript-api/: STM32G0_GPIO-api.c PikaStdLib-api.c PikaStdDevice_CAN-api.c PikaStdLib_PikaObj-api.c STM32G0_PWM-api.c PikaStdData_Dict-api.c PikaPiZero_RGB-api.c pikaScript.c PikaStdDevice_SPI-api.c machine_PWM-api.c machine_Task-api.c PikaStdTask_Task-api.c PikaStdDevice_UART-api.c PikaStdDevice-api.c PikaStdDevice_IIC-api.c PikaStdDevice_GPIO-api.c STM32G0_lowLevel-api.c PikaDebug-api.c PikaStdDevice_PWM-api.c machine_GPIO-api.c machine-api.c STM32G0_IIC-api.c PikaStdData_List-api.c PikaPiZero_Point-api.c STM32G0-api.c PikaStdDevice_Time-api.c machine_KEY-api.c machine_LCD-api.c PikaPiZero-api.c PikaDebug_Debuger-api.c PikaStdLib_RangeObj-api.c PikaMain-api.c STM32G0_UART-api.c STM32G0_Time-api.c machine_Time-api.c PikaStdData-api.c PikaStdData_ByteArray-api.c PikaStdData_Utils-api.c PikaStdLib_StringObj-api.c PikaPiZero_LCD-api.c machine_ADC-api.c PikaStdData_String-api.c machine_Point-api.c STM32G0_Task-api.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdDevice_ADC-api.c PikaStdTask-api.c machine_UART-api.c machine_RGB-api.c PikaPiZero_KEY-api.c __asset_pikaModules_py_a.c STM32G0_ADC-api.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdDevice/: PikaStdDevice_IIC.c PikaStdDevice_ADC.c PikaStdDevice_GPIO.c PikaStdDevice_CAN.c PikaStdDevice_Time.c PikaStdDevice_UART.c PikaStdDevice_PWM.c PikaStdDevice_SPI.c
    ../pikascript/pikascript-lib/STM32G0/: STM32G0_common.c STM32G0_UART.c STM32G0_Task.c STM32G0_ADC.c STM32G0_IIC.c STM32G0_Time.c STM32G0_GPIO.c STM32G0_PWM.c
    ../pikascript/pikascript-lib/PikaPiZero/: PikaPiZero_RGB.c PikaPiZero_KEY.c arm2d_config.c PikaPiZero_LCD.c LCD_Driver.c RGB_ASM.lib
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_RangeObj.c PikaStdData_Dict.c PikaStdTask_Task.c PikaStdLib_StringObj.c PikaStdLib_MemChecker.c PikaDebuger_Debuger.c PikaStdData_String.c PikaStdData_Utils.c PikaStdData_List.c PikaStdLib_SysObj.c
  group pikascript-core
    ../pikascript/pikascript-core/: TinyObj.c PikaObj.c dataStrs.c dataString.c dataMemory.c dataLinkNode.c dataLink.c dataArgs.c dataArg.c BaseObj.c dataQueue.c dataQueueObj.c PikaParser.c PikaVM.c dataStack.c PikaPlatform.c PikaCompiler.c
  group Python
    ../pikascript/: main.py PikaPiZero.pyi PikaStdDevice.pyi PikaStdLib.pyi STM32G0.pyi
software components: CMSIS:CORE 5.5.0
