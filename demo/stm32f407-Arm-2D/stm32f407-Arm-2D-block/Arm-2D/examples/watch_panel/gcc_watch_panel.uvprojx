# Keil uVision project gcc_watch_panel.uvprojx, settings and files
target STM32F746G-Discovery-GCC (6160000::V6.16::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: gcc_template +hex
  AfterMake: arm-none-eabi-size.exe ./Objects/gcc_template.elf
  group Application
    ./: example_gui.c example_gui.h app_cfg.h main.c
  group Platform
    ./platform/: GLCD_Fonts.c app_platform.c lcd_printf.c lcd_printf.h platform.h
    ./platform/lib/: libperf_counter_gcc.a perf_counter.h perf_counter.c systick_wrapper_gcc.s
  group Arm-2D
    ../../Library/Include/: __arm_2d_impl.h __arm_2d_paving.h __arm_2d_paving_helium.h arm_2d.h arm_2d_alpha_blending.h arm_2d_conversion.h arm_2d_draw.h arm_2d_features.h arm_2d_tile.h arm_2d_types.h arm_2d_utils.h arm_2d_rotation.h
    ../../Library/Source/: __arm_2d_alpha_blending.inc __arm_2d_copy.inc __arm_2d_draw_pattern.inc __arm_2d_fill_colour.inc arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_helium.c arm_2d_op_table.c arm_2d_tile.c arm_2d_rotation.c
  group Arm-2D-Helper
    ../../Helper/Source/: arm_2d_helper_pfb.c
    ../../Helper/Include/: arm_2d_helper_pfb.h arm_2d_helper.h
  group Control
    ./controls/: busy_wheel.c busy_wheel.h controls.c controls.h
  group asset
    ./asset/: arrow.c background.c clockface.c gear_01.c gear_02.c pointer_sec.c watch_panel.c whilte_dot.c.c
  group bsp_mps2
    ./platform/mps2/: GLCD_V2M-MPS2.c platform_mps2.c stdout_USART.c
  group bsp_stm32f746_discovery
    ./platform/stm32f746g-discovery/: startup_ARMCM7.c platform_stm32f746g_discovery.c GLCD_746G_Discovery.c
    ./RTE/Device/STM32F746NGHx/: system_stm32f7xx.c
target V2M-MPS2-CM0+ (6160000::V6.16::ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: gcc_template +hex
  AfterMake: arm-none-eabi-size.exe ./Objects/gcc_template.elf
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:Startup 2.0.3, Board Support:Drivers:SDRAM 1.1.1, CMSIS Driver:USART 1.16.0, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:LTDC 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:SDRAM 1.2.8, Device:STM32Cube HAL:USART 1.2.8, Device:STM32Cube LL:Common 1.2.8, Device:STM32Cube LL:PWR 1.2.8, Device:STM32Cube LL:RCC 1.2.8, Device:STM32Cube LL:USART 1.2.8, Device:STM32Cube LL:UTILS 1.2.8, Device:Startup 1.2.5
