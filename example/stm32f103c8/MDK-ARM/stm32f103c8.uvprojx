# Keil uVision project stm32f103c8.uvprojx, settings and files
target stm32f103c8 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32f103c8 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,HAL_ADC_MODULE_ENABLED,HAL_UART_MODULE_ENABLED,HAL_TIM_MODULE_ENABLED
  c include: ../Core/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Drivers/CMSIS/Include;  ..\pikascript\pikascript-core;  ..\pikascript\pikascript-lib\STM32;  ..\pikascript\pikascript-api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group pikascript-core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataString.c dataStrs.c method.c PikaBlock.c PikaIf.c PikaInvoke.c PikaObj.c PikaWhile.c TinyObj.c
  group pikascript-api
    ../pikascript/pikascript-api/: PikaMain-api.c pikaScript.c PikaStdDevice_ADC-api.c PikaStdDevice_GPIO-api.c PikaStdDevice_Time-api.c PikaStdDevice_UART-api.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c STM32_ADC-api.c STM32_GPIO-api.c STM32_Time-api.c STM32_UART-api.c PikaStdDevice_PWM-api.c STM32_PWM-api.c
  group pikascript-lib
    ../pikascript/pikascript-lib/STM32/: STM32_ADC.c STM32_common.c STM32_GPIO.c STM32_Time.c STM32_UART.c STM32_PWM.c
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_MemChecker.c PikaStdLib_SysObj.c
    ../pikascript/pikascript-lib/PikaStdDevice/: PikaStdDeivce_GPIO.c PikaStdDevice_ADC.c PikaStdDevice_Time.c PikaStdDevice_UART.c PikaStdDevice_PWM.c
software components: CMSIS:CORE 5.3.0
