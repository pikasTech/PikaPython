# Keil uVision project stm32g030c8.uvprojx, settings and files
target stm32g030c8 (6160000::V6.16::ARMCLANG)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g030c8 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx,HAL_ADC_MODULE_ENABLED,HAL_UART_MODULE_ENABLED,HAL_USART_MODULE_ENABLED,HAL_TIM_MODULE_ENABLED
  c include: ../Core/Inc;          ../Drivers/STM32G0xx_HAL_Driver/Inc;          ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;          ../Drivers/CMSIS/Include;          ..\pikascript\pikascript-core;          ..\pikascript\pikascript-api;          ..\pikascript\pikascript-lib\STM32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group pikascript-api
    ../pikascript/pikascript-api/: PikaMain-api.c pikaScript.c PikaStdDevice_ADC-api.c PikaStdDevice_GPIO-api.c PikaStdDevice_Time-api.c PikaStdDevice_UART-api.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c STM32_ADC-api.c STM32_GPIO-api.c STM32_Time-api.c STM32_UART-api.c PikaStdDevice_PWM-api.c STM32_PWM-api.c PikaPiZero_RGB-api.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdDevice/: PikaStdDeivce_GPIO.c PikaStdDevice_ADC.c PikaStdDevice_Time.c PikaStdDevice_UART.c PikaStdDevice_PWM.c
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_MemChecker.c PikaStdLib_SysObj.c
    ../pikascript/pikascript-lib/STM32/: STM32_ADC.c STM32_common.c STM32_GPIO.c STM32_Time.c STM32_UART.c STM32_PWM.c STM32_Code.c
    ../pikascript/pikascript-lib/PikaPiZero/: PikaPiZero_RGB.c RGB_ASM.lib
  group pikascript-core
    ../pikascript/pikascript-core/: TinyObj.c PikaWhile.c PikaObj.c PikaInvoke.c PikaIf.c PikaBlock.c method.c dataStrs.c dataString.c dataMemory.c dataLinkNode.c dataLink.c dataArgs.c dataArg.c BaseObj.c
software components: CMSIS:CORE 5.3.0
