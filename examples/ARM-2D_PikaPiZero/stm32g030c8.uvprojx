# Keil uVision project stm32g030c8.uvprojx, settings and files
target stm32g030c8 (6160000::V6.16::ARMCLANG)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g030c8 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32G030xx,USE_HAL_DRIVER
  c misc: -Wno-error=armcc-pragma-import -Wno-error=armcc-pragma-arm
  c include: ../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\pikascript\pikascript-core;..\pikascript\pikascript-api;..\pikascript\pikascript-lib\STM32;..\pikascript\pikascript-lib\STM32G030Booter;..\pikascript\pikascript-lib\PikaPiZero;..\pikascript\pikascript-lib\Arm2D;..\Drivers\CMSIS\DSP\Include
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Booter
    ../pikascript/pikascript-lib/STM32G030Booter/: gpio.c main.c stm32g0xx_hal_msp.c stm32g0xx_it.c system_stm32g0xx.c startup_stm32g030xx.s stm32g030_pika_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_ll_gpio.c stm32g0xx_ll_usart.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_MemChecker.c PikaStdLib_SysObj.c
    ../pikascript/pikascript-lib/PikaPiZero/: LCD_Driver.c
    ../pikascript/pikascript-lib/Arm2D/: Arm2D_Background.c Arm2D_Box.c Arm2D_common.c Arm2D_Element.c Arm2D_ElementList.c Arm2D_Window.c asset_corner_box.c asset_dot.c
  group pikascript-core
    ../pikascript/pikascript-core/: TinyObj.c PikaObj.c dataStrs.c dataString.c dataMemory.c dataLinkNode.c dataLink.c dataArgs.c dataArg.c BaseObj.c dataQueue.c dataQueueObj.c PikaParser.c PikaVM.c dataStack.c PikaPlatform.c
  group pikascript-api
    ../pikascript/pikascript-api/: PikaMain-api.c pikaScript.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdLib-api.c Arm2D_BackGround-api.c Arm2D_Box-api.c Arm2D_Element-api.c Arm2D_ElementList-api.c Arm2D_Window-api.c Arm2D-api.c
  group Drivers/Arm2D
    ../pikascript/pikascript-lib/Arm2D/: __arm_2d_core.c __arm_2d_tile.c arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_helium.c arm_2d_helper_pfb.c arm_2d_rotation.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c arm_cos_q31.c arm_sin_q31.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
software components: CMSIS:CORE 5.5.0
