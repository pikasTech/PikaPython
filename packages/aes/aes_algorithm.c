/* SPEC: PJ2026-050111 portable packages v0.3; FIPS 197 AES. */
#include "aes_algorithm.h"

#include <stddef.h>
#include <string.h>

static const uint8_t aes_sbox[256] = {
    0x63u,0x7cu,0x77u,0x7bu,0xf2u,0x6bu,0x6fu,0xc5u,0x30u,0x01u,0x67u,0x2bu,0xfeu,0xd7u,0xabu,0x76u,
    0xcau,0x82u,0xc9u,0x7du,0xfau,0x59u,0x47u,0xf0u,0xadu,0xd4u,0xa2u,0xafu,0x9cu,0xa4u,0x72u,0xc0u,
    0xb7u,0xfdu,0x93u,0x26u,0x36u,0x3fu,0xf7u,0xccu,0x34u,0xa5u,0xe5u,0xf1u,0x71u,0xd8u,0x31u,0x15u,
    0x04u,0xc7u,0x23u,0xc3u,0x18u,0x96u,0x05u,0x9au,0x07u,0x12u,0x80u,0xe2u,0xebu,0x27u,0xb2u,0x75u,
    0x09u,0x83u,0x2cu,0x1au,0x1bu,0x6eu,0x5au,0xa0u,0x52u,0x3bu,0xd6u,0xb3u,0x29u,0xe3u,0x2fu,0x84u,
    0x53u,0xd1u,0x00u,0xedu,0x20u,0xfcu,0xb1u,0x5bu,0x6au,0xcbu,0xbeu,0x39u,0x4au,0x4cu,0x58u,0xcfu,
    0xd0u,0xefu,0xaau,0xfbu,0x43u,0x4du,0x33u,0x85u,0x45u,0xf9u,0x02u,0x7fu,0x50u,0x3cu,0x9fu,0xa8u,
    0x51u,0xa3u,0x40u,0x8fu,0x92u,0x9du,0x38u,0xf5u,0xbcu,0xb6u,0xdau,0x21u,0x10u,0xffu,0xf3u,0xd2u,
    0xcdu,0x0cu,0x13u,0xecu,0x5fu,0x97u,0x44u,0x17u,0xc4u,0xa7u,0x7eu,0x3du,0x64u,0x5du,0x19u,0x73u,
    0x60u,0x81u,0x4fu,0xdcu,0x22u,0x2au,0x90u,0x88u,0x46u,0xeeu,0xb8u,0x14u,0xdeu,0x5eu,0x0bu,0xdbu,
    0xe0u,0x32u,0x3au,0x0au,0x49u,0x06u,0x24u,0x5cu,0xc2u,0xd3u,0xacu,0x62u,0x91u,0x95u,0xe4u,0x79u,
    0xe7u,0xc8u,0x37u,0x6du,0x8du,0xd5u,0x4eu,0xa9u,0x6cu,0x56u,0xf4u,0xeau,0x65u,0x7au,0xaeu,0x08u,
    0xbau,0x78u,0x25u,0x2eu,0x1cu,0xa6u,0xb4u,0xc6u,0xe8u,0xddu,0x74u,0x1fu,0x4bu,0xbdu,0x8bu,0x8au,
    0x70u,0x3eu,0xb5u,0x66u,0x48u,0x03u,0xf6u,0x0eu,0x61u,0x35u,0x57u,0xb9u,0x86u,0xc1u,0x1du,0x9eu,
    0xe1u,0xf8u,0x98u,0x11u,0x69u,0xd9u,0x8eu,0x94u,0x9bu,0x1eu,0x87u,0xe9u,0xceu,0x55u,0x28u,0xdfu,
    0x8cu,0xa1u,0x89u,0x0du,0xbfu,0xe6u,0x42u,0x68u,0x41u,0x99u,0x2du,0x0fu,0xb0u,0x54u,0xbbu,0x16u
};

static const uint8_t aes_inverse_sbox[256] = {
    0x52u,0x09u,0x6au,0xd5u,0x30u,0x36u,0xa5u,0x38u,0xbfu,0x40u,0xa3u,0x9eu,0x81u,0xf3u,0xd7u,0xfbu,
    0x7cu,0xe3u,0x39u,0x82u,0x9bu,0x2fu,0xffu,0x87u,0x34u,0x8eu,0x43u,0x44u,0xc4u,0xdeu,0xe9u,0xcbu,
    0x54u,0x7bu,0x94u,0x32u,0xa6u,0xc2u,0x23u,0x3du,0xeeu,0x4cu,0x95u,0x0bu,0x42u,0xfau,0xc3u,0x4eu,
    0x08u,0x2eu,0xa1u,0x66u,0x28u,0xd9u,0x24u,0xb2u,0x76u,0x5bu,0xa2u,0x49u,0x6du,0x8bu,0xd1u,0x25u,
    0x72u,0xf8u,0xf6u,0x64u,0x86u,0x68u,0x98u,0x16u,0xd4u,0xa4u,0x5cu,0xccu,0x5du,0x65u,0xb6u,0x92u,
    0x6cu,0x70u,0x48u,0x50u,0xfdu,0xedu,0xb9u,0xdau,0x5eu,0x15u,0x46u,0x57u,0xa7u,0x8du,0x9du,0x84u,
    0x90u,0xd8u,0xabu,0x00u,0x8cu,0xbcu,0xd3u,0x0au,0xf7u,0xe4u,0x58u,0x05u,0xb8u,0xb3u,0x45u,0x06u,
    0xd0u,0x2cu,0x1eu,0x8fu,0xcau,0x3fu,0x0fu,0x02u,0xc1u,0xafu,0xbdu,0x03u,0x01u,0x13u,0x8au,0x6bu,
    0x3au,0x91u,0x11u,0x41u,0x4fu,0x67u,0xdcu,0xeau,0x97u,0xf2u,0xcfu,0xceu,0xf0u,0xb4u,0xe6u,0x73u,
    0x96u,0xacu,0x74u,0x22u,0xe7u,0xadu,0x35u,0x85u,0xe2u,0xf9u,0x37u,0xe8u,0x1cu,0x75u,0xdfu,0x6eu,
    0x47u,0xf1u,0x1au,0x71u,0x1du,0x29u,0xc5u,0x89u,0x6fu,0xb7u,0x62u,0x0eu,0xaau,0x18u,0xbeu,0x1bu,
    0xfcu,0x56u,0x3eu,0x4bu,0xc6u,0xd2u,0x79u,0x20u,0x9au,0xdbu,0xc0u,0xfeu,0x78u,0xcdu,0x5au,0xf4u,
    0x1fu,0xddu,0xa8u,0x33u,0x88u,0x07u,0xc7u,0x31u,0xb1u,0x12u,0x10u,0x59u,0x27u,0x80u,0xecu,0x5fu,
    0x60u,0x51u,0x7fu,0xa9u,0x19u,0xb5u,0x4au,0x0du,0x2du,0xe5u,0x7au,0x9fu,0x93u,0xc9u,0x9cu,0xefu,
    0xa0u,0xe0u,0x3bu,0x4du,0xaeu,0x2au,0xf5u,0xb0u,0xc8u,0xebu,0xbbu,0x3cu,0x83u,0x53u,0x99u,0x61u,
    0x17u,0x2bu,0x04u,0x7eu,0xbau,0x77u,0xd6u,0x26u,0xe1u,0x69u,0x14u,0x63u,0x55u,0x21u,0x0cu,0x7du
};

static uint8_t aes_multiply(uint8_t left, uint8_t right) {
    uint8_t result = 0u;
    uint8_t value = left;
    uint8_t factor = right;
    while (factor != 0u) {
        if ((factor & 1u) != 0u) result ^= value;
        value = (uint8_t)((value << 1u) ^
                          ((value & 0x80u) != 0u ? 0x1bu : 0u));
        factor >>= 1u;
    }
    return result;
}

static void aes_add_round_key(uint8_t state[16],
                              const uint8_t* round_key) {
    uint32_t index;
    for (index = 0u; index < 16u; ++index) state[index] ^= round_key[index];
}

static void aes_substitute(uint8_t state[16]) {
    uint32_t index;
    for (index = 0u; index < 16u; ++index) state[index] = aes_sbox[state[index]];
}

static void aes_inverse_substitute(uint8_t state[16]) {
    uint32_t index;
    for (index = 0u; index < 16u; ++index) state[index] = aes_inverse_sbox[state[index]];
}

static void aes_shift_rows(uint8_t state[16]) {
    uint8_t value;
    value = state[1]; state[1] = state[5]; state[5] = state[9]; state[9] = state[13]; state[13] = value;
    value = state[2]; state[2] = state[10]; state[10] = value;
    value = state[6]; state[6] = state[14]; state[14] = value;
    value = state[15]; state[15] = state[11]; state[11] = state[7]; state[7] = state[3]; state[3] = value;
}

static void aes_inverse_shift_rows(uint8_t state[16]) {
    uint8_t value;
    value = state[13]; state[13] = state[9]; state[9] = state[5]; state[5] = state[1]; state[1] = value;
    value = state[2]; state[2] = state[10]; state[10] = value;
    value = state[6]; state[6] = state[14]; state[14] = value;
    value = state[3]; state[3] = state[7]; state[7] = state[11]; state[11] = state[15]; state[15] = value;
}

static void aes_mix_columns(uint8_t state[16]) {
    uint32_t column;
    for (column = 0u; column < 4u; ++column) {
        uint8_t* value = state + column * 4u;
        uint8_t all = (uint8_t)(value[0] ^ value[1] ^ value[2] ^ value[3]);
        uint8_t first = value[0];
        value[0] ^= all ^ aes_multiply((uint8_t)(value[0] ^ value[1]), 2u);
        value[1] ^= all ^ aes_multiply((uint8_t)(value[1] ^ value[2]), 2u);
        value[2] ^= all ^ aes_multiply((uint8_t)(value[2] ^ value[3]), 2u);
        value[3] ^= all ^ aes_multiply((uint8_t)(value[3] ^ first), 2u);
    }
}

static void aes_inverse_mix_columns(uint8_t state[16]) {
    uint32_t column;
    for (column = 0u; column < 4u; ++column) {
        uint8_t* value = state + column * 4u;
        uint8_t first = value[0];
        uint8_t second = value[1];
        uint8_t third = value[2];
        uint8_t fourth = value[3];
        value[0] = aes_multiply(first, 14u) ^ aes_multiply(second, 11u) ^ aes_multiply(third, 13u) ^ aes_multiply(fourth, 9u);
        value[1] = aes_multiply(first, 9u) ^ aes_multiply(second, 14u) ^ aes_multiply(third, 11u) ^ aes_multiply(fourth, 13u);
        value[2] = aes_multiply(first, 13u) ^ aes_multiply(second, 9u) ^ aes_multiply(third, 14u) ^ aes_multiply(fourth, 11u);
        value[3] = aes_multiply(first, 11u) ^ aes_multiply(second, 13u) ^ aes_multiply(third, 9u) ^ aes_multiply(fourth, 14u);
    }
}

PikaStatus pika_aes_initialize(PikaAesContext* context,
                               const uint8_t* key,
                               uint32_t key_length) {
    static const uint8_t round_constants[15] = {
        0x00u,0x01u,0x02u,0x04u,0x08u,0x10u,0x20u,0x40u,
        0x80u,0x1bu,0x36u,0x6cu,0xd8u,0xabu,0x4du
    };
    uint32_t key_words;
    uint32_t total_words;
    uint32_t word;
    if (context == NULL || key == NULL ||
        (key_length != 16u && key_length != 24u && key_length != 32u)) {
        return PIKA_STATUS_VALUE_ERROR;
    }
    memset(context, 0, sizeof(*context));
    key_words = key_length / 4u;
    context->rounds = (uint8_t)(key_words + 6u);
    total_words = 4u * ((uint32_t)context->rounds + 1u);
    memcpy(context->round_key, key, key_length);
    for (word = key_words; word < total_words; ++word) {
        uint8_t temporary[4];
        uint32_t index;
        memcpy(temporary, context->round_key + (word - 1u) * 4u, 4u);
        if (word % key_words == 0u) {
            uint8_t first = temporary[0];
            temporary[0] = aes_sbox[temporary[1]] ^ round_constants[word / key_words];
            temporary[1] = aes_sbox[temporary[2]];
            temporary[2] = aes_sbox[temporary[3]];
            temporary[3] = aes_sbox[first];
        } else if (key_words > 6u && word % key_words == 4u) {
            for (index = 0u; index < 4u; ++index) temporary[index] = aes_sbox[temporary[index]];
        }
        for (index = 0u; index < 4u; ++index) {
            context->round_key[word * 4u + index] =
                context->round_key[(word - key_words) * 4u + index] ^ temporary[index];
        }
    }
    return PIKA_STATUS_OK;
}

void pika_aes_encrypt_block(const PikaAesContext* context,
                            uint8_t block[16]) {
    uint32_t round;
    aes_add_round_key(block, context->round_key);
    for (round = 1u; round < context->rounds; ++round) {
        aes_substitute(block);
        aes_shift_rows(block);
        aes_mix_columns(block);
        aes_add_round_key(block, context->round_key + round * 16u);
    }
    aes_substitute(block);
    aes_shift_rows(block);
    aes_add_round_key(block, context->round_key + context->rounds * 16u);
}

void pika_aes_decrypt_block(const PikaAesContext* context,
                            uint8_t block[16]) {
    uint32_t round = context->rounds;
    aes_add_round_key(block, context->round_key + round * 16u);
    while (round > 1u) {
        --round;
        aes_inverse_shift_rows(block);
        aes_inverse_substitute(block);
        aes_add_round_key(block, context->round_key + round * 16u);
        aes_inverse_mix_columns(block);
    }
    aes_inverse_shift_rows(block);
    aes_inverse_substitute(block);
    aes_add_round_key(block, context->round_key);
}
