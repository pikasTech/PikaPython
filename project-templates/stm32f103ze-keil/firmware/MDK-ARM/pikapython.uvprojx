# Keil uVision project pikapython.uvprojx, settings and files
target PikaPython (6180000::V6.18::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PikaPython +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\pikapython-kernel;..\..\pikapython-generated
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c pika_entry.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group PikaPython Kernel
    ../../pikapython-kernel/: binding_engine.c binding_runtime.c builtin_registry.c builtin_runtime.c frontend_diagnostic.c frontend_graph.c frontend_lexer.c frontend_module.c frontend_parser.c kernel.c program_verifier.c register_engine.c repl_execution.c repl_session.c repl_shell_main.c repl_stream.c runtime_common.c script_main.c status.c text_method_runtime.c typed_engine.c value_output.c value_runtime.c verifier_object.c
  group PikaPython Generated
    ../../pikapython-generated/: pikapython_modules.c
software components: CMSIS:CORE 5.5.0
