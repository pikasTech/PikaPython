# Keil uVision project plooc_example.uvprojx, settings and files
target arm_compiler_6_example (6170000::V6.17::.\Arm Compiler 6.17)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: plooc_example
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER
  c misc: -fms-extensions
  c include: ..\mdk;..\..\..\example;..\..\trace;..\..\byte_queue;..\..\enhanced_byte_queue
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group platform
    ./: platform.c platform.h
    ../: main.c
  group byte_queue
    ../../byte_queue/: byte_queue.h byte_queue.c
  group enhanced_byte_queue
    ../../enhanced_byte_queue/: enhanced_byte_queue.c enhanced_byte_queue.h
  group trace
    ../../trace/: trace.h trace.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.2.2, Language Extension:PLOOC 4.5.9, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
